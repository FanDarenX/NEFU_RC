# Keil uVision project Engineering_Arm.uvprojx, settings and files
target Engineering_Arm (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Engineering_Arm +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../App;../Bsp;../support;../Task;../MDK-ARM;../../Engineering_Arm
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../App/: lqr.c lqr.h pid.c pid.h referee.c referee.h remote_control.c remote_control.h user_lib.c user_lib.h vodka.c vodka.h bsp_filter.c bsp_filter.h ui_interface.c ui_interface.h ui_types.h
    ../Core/Src/: Video_downlink.c
    ../Core/Inc/: Video_downlink.h
  group Bsp
    ../Bsp/: All_init.c All_init.h bsp_can.c bsp_rc.c bsp_rc.h bsp_usart.c bsp_usart.h struct_typedef.h dm_motor_ctrl.c dm_motor_ctrl.h bsp_can.h dm_motor_drv.c dm_motor_drv.h
  group Support
    ../support/: CRC8_CRC16.c CRC8_CRC16.h fifo.c fifo.h linux_list.h macro_mutex.h mem_mang.h mem_mang4.c protocol.h
  group Task
    ../App/: CAN_receive.c CAN_receive.h
    ../Task/: yaw_task.c yaw_task.h position_task.c position_task.h keyscan_task.c keyscan_task.h custom.c custom.h image_task.c image_task.h chassis_task.c chassis_task.h UI_Task.c UI_Task.h referee_usart_task.c referee_usart_task.h ui.h ui_g_Ungroup_0.c ui_g_Ungroup_0.h ui_g.c ui_g.h
    ../Core/Src/: Mapping.c Reset.c Behavior.c
    ../Core/Inc/: Mapping.h Reset.h Behavior.h
software components: CMSIS:CORE 6.1.0
